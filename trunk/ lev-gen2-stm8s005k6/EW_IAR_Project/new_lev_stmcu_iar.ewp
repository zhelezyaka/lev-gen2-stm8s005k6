# IAR project new_lev_stmcu_iar.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\STM8S_StdPeriph_Driver\inc; ..\src; ..\src\Drivers; ..\src\EEPROM_Setting; ..\src\IAR_Interrupt
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: new_lev_stmcu_iar.hex
  prebuild: ..\Bin_Tools\PreBuild.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: new_lev_stmcu_iar.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Drivers
    ../src/Drivers/: Adapter_SOC_Signal.c adc_read.c AWU_Timer_With_Halt_Mode.c button_control.c clk_setting.c Devices.h EEPROM_Access.c gpio_control.c led_pwm_control.c mosfet_control.c timer3.c uart2.c Uart_timer4_8bit.c
  group EEPROM
    ../src/EEPROM_Setting/: sys_info_eeprom.c SystemInformation.h
  group SOC
    ../src/SOC/: CoulombCounter.c SOC.h SOC_Calculation.c SOC_OCV_Table.h
  group Sources
    ../src/: DefinePollingFunctions.h Driver_Common_interface.c Global_config.h GolbalVariableArray.h LevG2_mainfun.c main.c Modbus_CRC.c Module_Driver_Define.h Module_Var_Bit_Define.h Module_Variable_Define.h ReceiveCmdParsing.c RecordingData.c stm8_interrupt_vector.c SubPolling_Protection.c TimerPollingFunctions.c
  group Sources/IAR_Interrupt
    ../src/IAR_Interrupt/: stm8s_it.c stm8s_it.h
  group ST_Libraries/Inc
    ../STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_awu.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_uart2.h
  group ST_Libraries/Src
    ../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c
  group SystemInformation
    ../src/SystemInformation/: SystemInfo.c SystemInfo.h User_Define.h User_Define_Parser.h
